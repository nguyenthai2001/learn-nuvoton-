# Keil uVision project NUC140_PCA9548.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NUC140_PCA9548 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\nuvoton\library2\Library\CMSIS\Include;C:\nuvoton\library2\Library\Device\Nuvoton\NUC100Series\Include;C:\nuvoton\library2\Library\SmartcardLib\Include;C:\nuvoton\library2\Library\StdDriver\inc;.\PCA9548_lib
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    C:/nuvoton/library2/Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
    C:/nuvoton/library2/Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group User
    ./: main.c
  group Library
    C:/nuvoton/library2/Library/StdDriver/src/: clk.c gpio.c i2c.c retarget.c sys.c timer.c uart.c
    ./PCA9548_lib/: PCA9548.c
software components: CMSIS:CORE 5.4.0
