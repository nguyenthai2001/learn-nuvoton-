# Keil uVision project I2C_GY30.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: I2C_GY30
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\library\NUC100BSP-master\Library\CMSIS\Include;.\library\NUC100BSP-master\Library\Device\Nuvoton\NUC100Series\Include;.\library\NUC100BSP-master\Library\SmartcardLib\Include;.\library\NUC100BSP-master\Library\StdDriver\inc;.\library\NUC100BSP-master\Library\lcd\inc;..\..\lcd_i2c\libraray;.\lib_Gy30
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./library/NUC100BSP-master/Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ./library/NUC100BSP-master/Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group User
    ./: main.c
  group Library
    ./library/NUC100BSP-master/Library/StdDriver/src/: clk.c adc.c gpio.c i2c.c retarget.c sys.c timer.c uart.c
    ./library/NUC100BSP-master/Library/lcd/src/: LCD_16X2.c
    ./lib_Gy30/: GY_30.c
    ../../lcd_i2c/libraray/: I2C_LCD.c
software components: CMSIS:CORE 5.6.0
