# Keil uVision project I2C_NEW.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: I2C_NEW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\NUC100_120BSPv3.00.002\Library\CMSIS\Include;..\..\NUC100_120BSPv3.00.002\Library\Device\Nuvoton\NUC100Series\Include;..\..\NUC100_120BSPv3.00.002\Library\NUC1xx-LB_002\inc;..\..\NUC100_120BSPv3.00.002\Library\SmartcardLib\Include;..\..\NUC100_120BSPv3.00.002\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../NUC100_120BSPv3.00.002/Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../NUC100_120BSPv3.00.002/Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group user
    ./: main.c
  group Library
    ../../NUC100_120BSPv3.00.002/Library/StdDriver/src/: clk.c adc.c gpio.c i2c.c retarget.c timer.c uart.c
software components: CMSIS:CORE 5.6.0
